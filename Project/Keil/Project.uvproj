# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Project +hex
  c flags: Optimize=8
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\User\lib;..\..\Hardware
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group Hardware
    ../../Hardware/: my_gpio.c tmr0.c tmr1.c tmr2.c tmr3.c tmr4.c uart0.c adc.c flash.c gpio_interrupt.c
  group User
    ../../User/: main.c my_config.h fun_info.c send_data.c pin_level_scan.c speed_scan.c engine_speed_scan.c mileage.c instruction.c ad_key.c fuel_capacity.c temp_of_water.c battery.c
